<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TADG.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>TADG</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>TADG</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>TADG</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


